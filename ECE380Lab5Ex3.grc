options:
  parameters:
    generate_options: qt_gui
    id: ECE380Lab5Ex1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude_max
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_scale
  id: variable
  parameters:
    value: (num_levels-1)/2
  states: {}
- name: audio_source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Audio Source
    label0: Wav File
    label1: Tone
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: num_levels
  id: variable_qtgui_range
  parameters:
    label: Number of Levels
    start: '3'
    step: '1'
    stop: '256'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude_max
    freq: '400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-analog_scale'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.95/analog_scale
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.95'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\aslator\Downloads\Intro_to_the_Universal_Declaration_of_Human_Rights_48k (1) (2).wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """Uniform quantization

          Source : Based on Section 2.2.2.2 of Meinhard Mueller's Fundamentals of Music Processing
          
          https://www.audiolabs-erlangen.de/resources/MIR/FMP/C2/C2S2_DigitalSignalQuantization.html

          Notebook: C2/C2S2_DigitalSignalQuantization.ipynb

          Args:
              x (np.ndarray): Original signal
              quant_min (float): Minimum quantization level (Default value = -1.0)
              quant_max (float): Maximum quantization level (Default value = 1.0)
              quant_level (int): Number of quantization levels (Default value = 5)

          Returns:
              x_quant (np.ndarray): Quantized signal
      """

      import numpy as np
      import math
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block implementing quantization up to 8 bits"""

          def __init__(self, quant_min=-1.0, quant_max=1.0, quant_level=5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Quantize Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.quant_min = quant_min
              self.quant_max = quant_max
              self.quant_level = quant_level
              print(quant_level)

          def work(self, input_items, output_items):
              """Using the provided parameters, normalize, quantize, and scale the input samples"""
              x_normalize = (input_items[0] - self.quant_min) * (self.quant_level-1) / (self.quant_max-self.quant_min)
              x_normalize[x_normalize > self.quant_level - 1] = self.quant_level - 1
              x_normalize[x_normalize < 0] = 0
              """We want integer values, so round to the nearest integer"""
              x_normalize_quant = np.around(x_normalize)
              
              output_items[0][:] = x_normalize_quant
              return len(output_items[0])
    quant_level: num_levels
    quant_max: amplitude_max
    quant_min: '-1*amplitude_max'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Analog Signal
    label2: Difference
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_level: analog_scale
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_selector_0, '0', epy_block_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [epy_block_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
