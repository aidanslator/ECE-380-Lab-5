options:
  parameters:
    generate_options: qt_gui
    id: ECE380Lab5Ex1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: a
    start: '0'
    step: '1'
    stop: '255'
    value: '1'
  states: {}
- name: amplitude_max
  id: variable
  parameters:
    value: '1'
  states: {}
- name: audio_source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Audio Source
    label0: Wav File
    label1: Tone
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: num_levels
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    start: '3'
    step: '1'
    stop: '256'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1*(num_levels-1)/2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/(num_levels-1)
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\aslator\Downloads\Intro_to_the_Universal_Declaration_of_Human_Rights_48k_Alaw.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """Uniform quantization

          Source : Based on Section 2.2.2.2 of Meinhard Mueller's Fundamentals of Music Processing
          
          https://www.audiolabs-erlangen.de/resources/MIR/FMP/C2/C2S2_DigitalSignalQuantization.html

          Notebook: C2/C2S2_DigitalSignalQuantization.ipynb

          Args:
              x (np.ndarray): Original signal
              quant_min (float): Minimum quantization level (Default value = -1.0)
              quant_max (float): Maximum quantization level (Default value = 1.0)
              quant_level (int): Number of quantization levels (Default value = 5)

          Returns:
              x_quant (np.ndarray): Quantized signal
      """

      import numpy as np
      import math
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block implementing quantization up to 8 bits"""

          def __init__(self, quant_min=-1.0, quant_max=1.0, quant_level=5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Quantize Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.quant_min = quant_min
              self.quant_max = quant_max
              self.quant_level = quant_level
              print(quant_level)

          def work(self, input_items, output_items):
              """Using the provided parameters, normalize, quantize, and scale the input samples"""
              x_normalize = (input_items[0] - self.quant_min) * (self.quant_level-1) / (self.quant_max-self.quant_min)
              x_normalize[x_normalize > self.quant_level - 1] = self.quant_level - 1
              x_normalize[x_normalize < 0] = 0
              """We want integer values, so round to the nearest integer"""
              x_normalize_quant = np.around(x_normalize)
              
              output_items[0][:] = x_normalize_quant
              return len(output_items[0])
    quant_level: num_levels
    quant_max: amplitude_max
    quant_min: '-1*amplitude_max'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    A: a
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\ndef A_Law_Compress(input,A)-> np.ndarray: \n    if(A <= 0):\n        return input\n    \n    denominator = 1+np.log(A)\n    \n    output = []\n    for g in input:\n        if(np.abs(g) < 1/A):\n            v = np.sign(g)*A*np.abs(g)/denominator\n        else:\n            v = np.sign(g)*(1+np.log(A*np.abs(g)))/denominator    \n        output.append(v)\n    return output\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple A law compressor\"\"\"\n\n    def __init__(self, A=1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='A Law Compressor',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.A = A\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = A_Law_Compress(input_items[0],self.A)\n        return len(output_items[0])\n\n "
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    A: a
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      def A_Law_Expansion(input,A) -> np.ndarray: 

          if(A <= 0):
              return input
              
          output = []
          for v in input:
              if(np.abs(v) < 1/(1 + np.log(A))):
                  g = np.sign(v)*np.abs(v)*(1 + np.log(A))/A
              else:
                  g = np.sign(v)*np.exp(-1 + np.abs(v)*(1 + np.log(A)))/A    
              output.append(g)
          return output

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, A=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='A Log Expander',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.A = A

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = A_Law_Expansion(input_items[0],self.A)
              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,4
    label1: Expanded Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,4
    label1: Compressed Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_2, '0']
- [blocks_selector_0, '0', epy_block_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [epy_block_0, '0', blocks_uchar_to_float_0, '0']
- [epy_block_1, '0', epy_block_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1_0, '0']
- [epy_block_2, '0', audio_sink_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
