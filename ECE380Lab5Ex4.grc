options:
  parameters:
    generate_options: qt_gui
    id: ECE380Lab5Ex1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: a
    start: '0'
    step: '1'
    stop: '255'
    value: '1'
  states: {}
- name: audio_source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Audio Source
    label0: Wav File
    label1: Tone
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: compression_method
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Compression Method
    label0: u Law
    label1: A Law
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: u
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: u
    start: '0'
    step: '1'
    stop: '255'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: compression_method
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\aslator\Downloads\Intro_to_the_Universal_Declaration_of_Human_Rights_48k (1) (2).wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\ndef u_Law_Compress(input,u) -> np.ndarray:\n    if(u <= 0):\n        return input\n    return np.sign(input) * np.log(1+u*np.abs(input))/(np.log(1+u))\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple u law compressor\"\"\"\n\n    def __init__(self, u=1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='u_law_compressor',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32],\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.u = u\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = u_Law_Compress(input_items[0],self.u)\n        return len(output_items[0])\n\n\n"
    u: u
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    A: a
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\ndef A_Law_Compress(input,A)-> np.ndarray: \n    if(A <= 0):\n        return input\n    \n    denominator = 1+np.log(A)\n    \n    output = []\n    for g in input:\n        if(np.abs(g) < 1/A):\n            v = np.sign(g)*A*np.abs(g)/denominator\n        else:\n            v = np.sign(g)*(1+np.log(A*np.abs(g)))/denominator    \n        output.append(v)\n    return output\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple A law compressor\"\"\"\n\n    def __init__(self, A=1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='A Law Compressor',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.A = A\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = A_Law_Compress(input_items[0],self.A)\n        return len(output_items[0])\n\n "
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,4
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', epy_block_0, '0']
- [blocks_selector_0, '0', epy_block_1, '0']
- [blocks_selector_0_0, '0', audio_sink_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [epy_block_0, '0', blocks_selector_0_0, '0']
- [epy_block_1, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
